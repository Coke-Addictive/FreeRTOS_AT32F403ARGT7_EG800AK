# Keil uVision project AT32F403ARGT7_EG800AK.uvprojx, settings and files
target AT32F403ARGT7_EG800AK (6240000::V6.24::ARMCLANG)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ARGT7_EG800AK +hex
  AfterMake: ./Keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403ARGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c misc: -fno-finite-math-only
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\Treo\Common;..\..\Treo\Board;..\..\Treo\Driver;..\..\Treo\Service;..\..\Treo\App;..\..\Treo\System;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_debug.c wk_exint.c wk_usart.c wk_dma.c wk_gpio.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_xmc.c at32f403a_407_emac.c at32f403a_407_sdio.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group Common
    ../../Treo/Common/: cJSON.c cJSON.h log.c log.h lwrb.c lwrb.h md5.c md5.h sm4.c sm4.h types.h
  group Board
    ../../Treo/Board/: board_eg.h
  group Driver
    ../../Treo/Driver/: drv_eg.c drv_eg.h
  group Service
    ../../Treo/Service/: eg_service_cfg.h eg_service.c eg_service.h eg_basic.c eg_basic.h eg_network.c eg_network.h eg_mqtt.c eg_mqtt.h eg_http.c eg_http.h eg_timer.c eg_timer.h eg_locate.c eg_locate.h
  group App
    ../../Treo/App/: app_eg.c app_eg.h
  group System
    ../../Treo/System/: system_main.c system_main.h system_version.h
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
